ELETTRA_ACCOUNTS = " \
    lorenzo.pivetta \
    alessio.bogani \
    giulio.gaio \
    graziano.scalamera \
    claudio.scafuri \
    alessandro.abrami \
    martin.scarcia \
    adriano.contillo \
    igor.trovarelli \
    maurizio.bossi \
    "

ELETTRA_SUDO_ACCOUNTS = " \
    lorenzo.pivetta \
    alessio.bogani \
    "
