FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

#SRC_URI:append = " \
#	file://grub.cfg \
#	"
#
#SRC_URI:append:d-6244 = " \
#	file://grub.cfg \
#	"
#
#SRC_URI:append:d-6346 = " \
#	file://grub.cfg \
#	"
#
#SRC_URI:append:s-4125r = " \
#	file://grub.cfg \
#	"
#
#SRC_URI:append:s-4305ue = " \
#	file://grub.cfg \
#	"
