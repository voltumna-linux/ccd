SYSTEMD_AUTO_ENABLE:${PN}-server-snmpd = "enable"
